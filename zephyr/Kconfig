## zephyr/Kconfig
```kconfig
if INTEL_HAL

menu "Intel HAL Zephyr Configuration"

rsource "subsys/logging/backends/Kconfig.i2c"
rsource "bsp_sedi/Kconfig"
```
